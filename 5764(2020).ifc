Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-01-22T16:07:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 22 16:07:10 2020 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{02C6FB52-421A-45B7-A79E-01C261457A62}\ifc * Database version: 5507 * Database creation date: Wed Jan 22 16:07:09 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 22 16:07:10 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 22 16:07:10 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 5764 Shower faucet, 160cc, 5764(2020):5764 Shower faucet, 160cc:395934
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - NominalDepth: 74.9124 mm; NominalHeight: 59.9583 mm; NominalWidth: 289.167 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 5764(2020); ConvergoRefNr: 0087-1911-0009-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 04/12/2019
Type - Green Building Properties(Type) - Backflow Prevention EN1717: EB; Customs Code: 84818011; EAN Number: 6414150091346; EN Standard: EN 1111; LVI Number: 6310866
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/5764; Catalog Drawing URL: http://static.oras.com/catdrw/5764; Class: Thermostatic; Dimension Drawing URL: http://static.oras.com/dimdrw/5764; FDV Document URL: http://www.oras.com/datasheet/5764/en/fdv; Group: Shower faucets; Manufacturer: Oras; Market: SWE; Model: 5764 Shower faucet, 160cc; Name_en: 5764 Shower faucet, 160cc; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 294 x 164 x 83; Package Weight: 2.250 kg; Product Code: 5764; Product Datasheet: http://www.oras.com/datasheet/5764/en; Product Family: Oras Care; Product Image URL: http://static.oras.com/image/5764; Product URL: http://static.oras.com/5764; Type Name: 5764 Shower faucet, 160cc; Usage Group: Households
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: DZR brass; Connection: Direct Connection; Connection Size: M26x1.5; Installation and Maintenance: http://static.oras.com/manual/5764; Installation Type: Wall mounted; Installation Width: CC160; Lever Handle: Temperature control handle;Flow control handle;; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Ceramic head part;Non-return valve(s); Mounting Holes: 2MountingHoles; Not Included: Without Couplings; Spare Parts: http://static.oras.com/sp/5764
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 5764(2020); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 5764; Name: 5764 Shower faucet, 160cc; ReplacementCost: n/a; Shape: Sculptured; Size: 290x75x60 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Text(Type) - Safety Sales Arguments: THERMO COOL. Improved safety – the housing of the fittings conducts minimal heat.
Pset_ManufacturerTypeInformation - ModelReference: 5764; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 5764 Shower faucet, 160cc
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0521757 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 20 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00159705 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 5764(2020): 5764 Shower faucet, 160cc; Family and Type: 5764(2020): 5764 Shower faucet, 160cc; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 5764(2020): 5764 Shower faucet, 160cc; Type Id: 5764(2020): 5764 Shower faucet, 160cc; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
